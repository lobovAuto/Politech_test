# Keil uVision project Polytech_test.uvprojx, settings and files
target gd32f405 (6160000::V6.16::ARMCLANG)
  device: GD32F405RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Polytech_test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wall -Werror -Wextra -pedantic
  c include: ..\Libs\GD32F4xx_standard_peripheral\Source;..\Libs\GD32F4xx_standard_peripheral\Include;..\..\Politech_test;..\Libs\CMSIS\GD\GD32F4xx\Source\ARM;..\Libs\CMSIS\GD\GD32F4xx\Include;..\Libs\CMSIS;..\Main\Src;..\Main\Inc;..\Drivers\MAX6691\Src;..\Drivers\MAX6691\Inc;..\Drivers\USART\Src;..\Drivers\USART\Inc;..\MathFunction\LookupTable\Src;..\MathFunction\LookupTable\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libs/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f405_425.s
  group CMSIS
    ../Libs/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group SPL
    ../Libs/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c gd32f4xx_can.c
  group Main
    ../Main/Src/: main.c
  group Drivers
    ../Drivers/MAX6691/Src/: max6691.c
    ../Drivers/USART/Src/: USART.c
  group Math
    ../MathFunction/LookupTable/Src/: LookupTable.c
